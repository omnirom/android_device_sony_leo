## omni_defconfig
```kconfig
CONFIG_DEBUG_FS=y
CONFIG_F2FS_FS=y
CONFIG_F2FS_FS_SECURITY=y
CONFIG_F2FS_CHECK_FS=y
CONFIG_F2FS_FS_XATTR=y
```
